# Keil uVision project Template.uvprojx, settings and files
target Template (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: M0516LDN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.1.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: template
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c misc: --cpp11    --c99
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\M051Series\Include;..\..\..\Library\StdDriver\inc;.\user\FT_Esd_Framework;.\user\FT_Esd_Widgets;.\user\page;.\user\HAL
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M051Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group User
    ./user/: main.c
  group FT_Esd_Framework
    ./user/FT_Esd_Framework/: Ft_Esd_Theme.c FT_Esd_App.c FT_Esd_MainLoop.c Ft_Esd_CoCmd.c FT_Esd_Dl.c Ft_Esd_Timer.c Ft_Esd_Widget.c Ft_Esd_TouchTag.c Ft_Esd_Math.c Ft_Esd.c Ft_Esd_Layout_Switch.c Ft_Esd_Layout_Fixed.c Ft_Esd_Layout_Display.c Ft_Esd_Layout_Linear.c Ft_Esd_Layout_Stretch__Generated.c
  group FT_Esd_Widgets
    ./user/FT_Esd_Widgets/: Ft_Esd_Label__Generated.c Ft_Esd_Theme_DarkOrange.c Ft_Esd_Theme_LightBlue.c Ft_Esd_LabelButton__Generated.c Ft_Esd_LabelButton.c Ft_Esd_PushButton__Generated.c Ft_Esd_SpinBox__Generated.c
    ./user/FT_Esd_Framework/: Ft_Esd_GpuAlloc.c
  group page
    ./user/page/: App__Generated.c AppScreen__Generated.c DefaultTheme.c MainPage__Generated.c
  group HAL
    ./user/HAL/: FT_CoPro_Cmds.c FT_Emu_main.c FT_Gpu_Hal.c
software components: CMSIS:CORE 5.0.0, Device:Driver:CLK 3.01.001, Device:Driver:FMC 3.01.001, Device:Driver:GPIO 3.01.001, Device:Driver:SPI 3.01.001, Device:Driver:SYS 3.01.001, Device:Driver:UART 3.01.001, Device:Startup 3.01.001
